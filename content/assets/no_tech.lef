VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

PROPERTYDEFINITIONS
  MACRO CatenaDesignType STRING ;
END PROPERTYDEFINITIONS

MACRO DFF_async_set_reset
  CLASS CORE ;
  ORIGIN -5.2 -6.7 ;
  FOREIGN DFF_async_set_reset 5.2 6.7 ;
  SIZE 84.85 BY 27.7 ;
  SYMMETRY X Y ;
  SITE CoreSite ;
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN SET
    DIRECTION INPUT ;
    USE ANALOG ;
  END SET
  PIN RST
    DIRECTION INPUT ;
    USE SIGNAL ;
  END RST
  PIN Q
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Q
  PIN D
    DIRECTION INPUT ;
    USE SIGNAL ;
  END D
  PIN CLK
    DIRECTION INPUT ;
    USE CLOCK ;
  END CLK
  OBS
    LAYER MET1 ;
      RECT 86.95 26.1 88.75 27.9 ;
      RECT 87.45 14.01 88.25 27.9 ;
      RECT 87.45 20.85 89.25 22.65 ;
      RECT 86.95 14.01 88.75 15.81 ;
      RECT 81.75 26.1 83.55 27.9 ;
      RECT 82.26 22.18 83.06 27.9 ;
      RECT 84.85 22.95 86.65 24.75 ;
      RECT 82.26 23.45 86.65 24.25 ;
      RECT 79.66 22.18 83.06 22.98 ;
      RECT 76.2 20.85 78 22.65 ;
      RECT 79.66 14.01 80.46 22.98 ;
      RECT 76.2 21.35 80.46 22.15 ;
      RECT 79.15 14.01 80.95 15.81 ;
      RECT 84.35 14.01 86.15 15.81 ;
      RECT 81.75 14.01 83.55 15.81 ;
      RECT 76.55 14.01 78.35 15.81 ;
      RECT 71.35 14.01 73.15 15.81 ;
      RECT 56.18 14.01 57.98 15.81 ;
      RECT 46.69 14.01 48.49 15.81 ;
      RECT 36.95 14.01 38.75 15.81 ;
      RECT 31.75 14.01 33.55 15.81 ;
      RECT 29.15 14.01 30.95 15.81 ;
      RECT 23.95 14.01 25.75 15.81 ;
      RECT 6.5 14.01 8.3 15.81 ;
      RECT 84.85 6.7 85.65 15.81 ;
      RECT 82.25 6.7 83.05 15.81 ;
      RECT 77.05 6.7 77.85 15.81 ;
      RECT 71.85 6.7 72.65 15.81 ;
      RECT 56.68 6.7 57.48 15.81 ;
      RECT 47.32 6.7 48.12 15.81 ;
      RECT 37.45 6.7 38.25 15.81 ;
      RECT 32.25 6.7 33.05 15.81 ;
      RECT 29.65 6.7 30.45 15.81 ;
      RECT 24.45 6.7 25.25 15.81 ;
      RECT 7 6.7 7.8 15.81 ;
      RECT 6.4 6.7 86.2 8.5 ;
      RECT 6.4 31.9 86.2 33.7 ;
      RECT 84.85 26.1 85.65 33.7 ;
      RECT 77.05 26.1 77.85 33.7 ;
      RECT 56.68 26.1 57.48 33.7 ;
      RECT 47.24 26.1 48.04 33.7 ;
      RECT 32.25 26.1 33.05 33.7 ;
      RECT 29.65 26.1 30.45 33.7 ;
      RECT 7 26.1 7.8 33.7 ;
      RECT 84.35 26.1 86.15 27.9 ;
      RECT 76.55 26.1 78.35 27.9 ;
      RECT 56.18 26.1 57.98 27.9 ;
      RECT 46.69 26.1 48.49 27.9 ;
      RECT 31.75 26.1 33.55 27.9 ;
      RECT 29.15 26.1 30.95 27.9 ;
      RECT 6.5 26.1 8.3 27.9 ;
      RECT 71.35 26.1 73.15 27.9 ;
      RECT 71.85 21.87 72.65 27.9 ;
      RECT 71.35 22.67 73.15 24.47 ;
      RECT 74.45 14.01 75.25 22.67 ;
      RECT 71.85 21.87 75.25 22.67 ;
      RECT 73.95 14.01 75.75 15.81 ;
      RECT 59.28 30.3 73.95 31.1 ;
      RECT 72.65 28.89 74.45 30.69 ;
      RECT 59.28 23.5 60.08 31.1 ;
      RECT 58.78 26.1 60.58 27.9 ;
      RECT 59.13 23.5 60.93 25.3 ;
      RECT 52.31 23.5 54.11 25.3 ;
      RECT 59.63 21.9 60.43 25.3 ;
      RECT 53.06 21.9 53.86 25.3 ;
      RECT 53.06 21.9 60.43 22.7 ;
      RECT 64.68 28.7 70.18 29.5 ;
      RECT 69.38 12.41 70.18 29.5 ;
      RECT 64.68 26.1 65.48 29.5 ;
      RECT 64.18 26.1 65.98 27.9 ;
      RECT 69.38 19.27 72.15 21.07 ;
      RECT 64.18 14.01 65.98 15.81 ;
      RECT 64.68 12.41 65.48 15.81 ;
      RECT 64.68 12.41 70.18 13.21 ;
      RECT 66.78 26.1 68.58 27.9 ;
      RECT 67.28 14.01 68.08 27.9 ;
      RECT 66.28 22.67 68.08 24.47 ;
      RECT 66.78 14.01 68.58 15.81 ;
      RECT 61.58 26.1 63.38 27.9 ;
      RECT 62.08 14.01 62.88 27.9 ;
      RECT 56.73 20.3 62.88 21.1 ;
      RECT 56.73 18.2 57.53 21.1 ;
      RECT 53.46 18.2 57.53 19 ;
      RECT 53.46 11.68 54.26 19 ;
      RECT 61.58 14.01 63.38 15.81 ;
      RECT 49.16 11.29 50.96 13.09 ;
      RECT 49.16 11.68 54.26 12.48 ;
      RECT 59.13 17.7 60.93 19.5 ;
      RECT 59.28 14.01 60.08 19.5 ;
      RECT 58.78 14.01 60.58 15.81 ;
      RECT 49.29 26.1 51.09 27.9 ;
      RECT 49.79 21.59 50.59 27.9 ;
      RECT 50.59 16.65 51.39 22.39 ;
      RECT 50.59 16.65 52.39 18.45 ;
      RECT 49.79 14.01 50.59 18.17 ;
      RECT 49.29 14.01 51.09 15.81 ;
      RECT 44.09 26.1 45.89 27.9 ;
      RECT 43.84 14.01 44.64 27.4 ;
      RECT 47.99 18.97 49.79 20.77 ;
      RECT 43.84 19.46 49.79 20.26 ;
      RECT 43.84 14.01 45.89 15.81 ;
      RECT 37.31 28.89 39.11 30.69 ;
      RECT 43.01 28.7 44.81 30.5 ;
      RECT 37.31 29.39 44.81 30.19 ;
      RECT 41.05 22.3 42.85 25.3 ;
      RECT 36.7 21.8 38.5 23.6 ;
      RECT 36.7 22.3 42.85 23.1 ;
      RECT 36.95 26.1 38.75 27.9 ;
      RECT 37.45 24.4 38.25 27.9 ;
      RECT 34.85 24.4 38.25 25.2 ;
      RECT 34.85 14.01 35.65 25.2 ;
      RECT 28.65 19.29 30.45 21.09 ;
      RECT 41.05 14.1 41.85 20.08 ;
      RECT 29.62 19.28 41.85 20.08 ;
      RECT 40.55 14.1 42.35 15.9 ;
      RECT 34.35 14.01 36.15 15.81 ;
      RECT 12.6 28.7 22.8 29.5 ;
      RECT 22 21.89 22.8 29.5 ;
      RECT 17.3 26.1 18.1 29.5 ;
      RECT 12.6 12.41 13.4 29.5 ;
      RECT 16.8 26.1 18.6 27.9 ;
      RECT 32.25 21.89 34.05 23.69 ;
      RECT 22 21.89 34.05 22.69 ;
      RECT 16.8 14.01 18.6 15.81 ;
      RECT 17.3 12.41 18.1 15.81 ;
      RECT 12.6 12.41 18.1 13.21 ;
      RECT 19.4 26.1 21.2 27.9 ;
      RECT 19.9 14.01 20.7 27.9 ;
      RECT 19.9 20.29 27.85 21.09 ;
      RECT 27.05 14.01 27.85 21.09 ;
      RECT 24.65 19.29 27.85 21.09 ;
      RECT 26.55 14.01 28.35 15.81 ;
      RECT 19.4 14.01 21.2 15.81 ;
      RECT 23.95 26.1 25.75 27.9 ;
      RECT 24.45 23.5 25.25 27.9 ;
      RECT 23.6 23.5 25.4 25.3 ;
      RECT 21.5 17.68 23.3 19.48 ;
      RECT 22 10.21 22.8 19.48 ;
      RECT 21.5 10.21 23.3 12.01 ;
      RECT 14.2 26.1 16 27.9 ;
      RECT 14.7 14.01 15.5 27.9 ;
      RECT 14.2 22.95 16 24.75 ;
      RECT 14.2 14.01 16 15.81 ;
      RECT 9.1 26.1 10.9 27.9 ;
      RECT 9.6 14.01 10.4 27.9 ;
      RECT 9.6 22.95 11.8 24.75 ;
      RECT 9.1 14.01 10.9 15.81 ;
      RECT 79.15 26.1 80.95 27.9 ;
      RECT 73.95 26.1 75.75 27.9 ;
      RECT 56.43 23.5 58.23 25.3 ;
      RECT 45.44 21.21 47.24 23.01 ;
      RECT 34.35 26.1 36.15 27.9 ;
      RECT 26.55 26.1 28.35 27.9 ;
      RECT 26.2 23.5 28 25.3 ;
      RECT 6.75 22.95 8.55 24.75 ;
  END
  PROPERTY CatenaDesignType "deviceLevel" ;
END DFF_async_set_reset

MACRO INV
  CLASS CORE ;
  ORIGIN 0.8 15.73 ;
  FOREIGN INV -0.8 -15.73 ;
  SIZE 7 BY 27.7 ;
  SYMMETRY X Y ;
  SITE CoreSite ;
  PIN Y
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Y
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  OBS
    LAYER MET1 ;
      RECT 0.5 -12.91 2.3 -11.11 ;
      RECT 0.51 -15.73 1.31 -11.11 ;
      RECT 0.51 -15.73 4.91 -13.93 ;
      RECT 3.1 6.1 4.9 7.9 ;
      RECT 4 -12.91 4.9 7.9 ;
      RECT 3.1 -12.91 4.9 -11.11 ;
      RECT 0.4 9.47 4.8 11.27 ;
      RECT 0.5 6.1 1.3 11.27 ;
      RECT 0.5 6.1 2.3 7.9 ;
      RECT 0.75 2.27 2.55 4.07 ;
  END
  PROPERTY CatenaDesignType "deviceLevel" ;
END INV

MACRO NAND
  CLASS CORE ;
  ORIGIN 0.8 9.17 ;
  FOREIGN NAND -0.8 -9.17 ;
  SIZE 9.6 BY 27.7 ;
  SYMMETRY X Y ;
  SITE CoreSite ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
  PIN Y
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Y
  PIN B
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  OBS
    LAYER MET1 ;
      RECT 0.5 -6.37 2.3 -4.57 ;
      RECT 1 -9.17 1.8 -4.57 ;
      RECT 0.5 -9.17 7.5 -7.37 ;
      RECT 3.6 5.2 4.4 13.75 ;
      RECT 3.1 11.55 4.9 13.35 ;
      RECT 3.6 5.2 7 6 ;
      RECT 6.2 -6.37 7 6 ;
      RECT 5.7 -6.37 7.5 -4.57 ;
      RECT 0.5 16.03 7.5 17.83 ;
      RECT 6.2 11.55 7 17.83 ;
      RECT 1 11.55 1.8 17.83 ;
      RECT 5.7 11.55 7.5 13.35 ;
      RECT 0.5 11.55 2.3 13.35 ;
      RECT 5.45 6.8 7.25 8.6 ;
      RECT 3.1 -6.37 4.9 -4.57 ;
      RECT 0.75 6.8 2.55 8.6 ;
  END
  PROPERTY CatenaDesignType "deviceLevel" ;
END NAND

MACRO NOR
  CLASS CORE ;
  ORIGIN 0.8 10.86 ;
  FOREIGN NOR -0.8 -10.86 ;
  SIZE 9.6 BY 27.7 ;
  SYMMETRY X Y ;
  SITE CoreSite ;
  PIN Y
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Y
  PIN VSS
    DIRECTION INOUT ;
    USE GROUND ;
  END VSS
  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
  END VDD
  PIN B
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  OBS
    LAYER MET1 ;
      RECT 5.7 9.86 8.3 11.66 ;
      RECT 7.5 4.57 8.3 11.66 ;
      RECT 3.6 4.57 8.3 5.37 ;
      RECT 3.6 -8.06 4.4 5.37 ;
      RECT 3.1 -8.06 4.9 -6.26 ;
      RECT 5.7 -8.06 7.5 -6.26 ;
      RECT 0.5 -8.06 2.3 -6.26 ;
      RECT 6.1 -10.86 7.1 -6.26 ;
      RECT 0.9 -10.86 1.9 -6.26 ;
      RECT 0.5 -10.86 7.5 -9.06 ;
      RECT 0.5 14.34 7.5 16.14 ;
      RECT 0.9 9.86 1.9 16.14 ;
      RECT 0.5 9.86 2.3 11.66 ;
      RECT 4.4 6.21 6.2 8.01 ;
      RECT 3.1 9.86 4.9 11.66 ;
      RECT 1.8 6.21 3.6 8.01 ;
  END
  PROPERTY CatenaDesignType "deviceLevel" ;
END NOR

END LIBRARY
